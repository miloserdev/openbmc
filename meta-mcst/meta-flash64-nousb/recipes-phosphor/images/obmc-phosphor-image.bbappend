IMAGE_FEATURES_remove = "obmc-ikvm"
OBMC_IMAGE_EXTRA_INSTALL_remove = "vncpasswd"
