FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += " file://0008-remove-virtual-media.patch "
