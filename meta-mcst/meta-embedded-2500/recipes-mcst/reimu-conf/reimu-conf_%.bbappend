FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://reimu.conf"
