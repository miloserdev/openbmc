OBMC_IMAGE_EXTRA_INSTALL_append = " \
  kernel-module-tinyspi \
  "
