FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += " file://0002-reset-2nd-boot-watchdog.patch "
