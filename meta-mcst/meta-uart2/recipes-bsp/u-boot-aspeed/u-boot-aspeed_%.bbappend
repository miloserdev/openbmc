FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://0002-serial-config-uart2.patch"
