OBMC_IMAGE_EXTRA_INSTALL_append += " \
  perf \
  tcpdump \
  ethtool \
  phosphor-webui \
  ipmitool \
  iptables \
  obmc-phosphor-buttons-signals \
  obmc-phosphor-buttons-handler \
  reimu-power-control \
  vncpasswd \
  sudo \
  "
