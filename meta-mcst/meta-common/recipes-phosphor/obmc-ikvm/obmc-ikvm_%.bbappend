FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://0000-allow-connect-from-all-ip-addresses.patch file://0001-add-vnc-auth.patch "
