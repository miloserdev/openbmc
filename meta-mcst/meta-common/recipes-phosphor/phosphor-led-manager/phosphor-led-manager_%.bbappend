FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += " file://0001-dont-use-fru-fault.patch "
