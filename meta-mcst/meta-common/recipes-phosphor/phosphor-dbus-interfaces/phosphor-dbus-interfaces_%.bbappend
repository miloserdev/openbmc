FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += " file://0001-enable-Domains-parameter.patch file://0001-enable-HardOff-transition.patch "
