FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += " file://0001-fix-power-commands.patch "
