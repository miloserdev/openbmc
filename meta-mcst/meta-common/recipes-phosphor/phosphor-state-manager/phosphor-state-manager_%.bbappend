FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += " file://0001-customize-for-reimu.patch "
