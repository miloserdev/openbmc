do_compile[vardepsexclude] += "VERSION VERSION_ID"
