DEPENDS += "openldap"
EXTRA_OECONF_remove = "--with-openldap=no"
