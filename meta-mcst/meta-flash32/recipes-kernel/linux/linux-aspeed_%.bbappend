FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://aspeed-bmc-mcst-flash32.dtsi file://0001-expand-initramfs-area.patch"
